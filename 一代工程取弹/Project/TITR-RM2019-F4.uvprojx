# Keil uVision project TITR-RM2019-F4.uvprojx, settings and files
target TITR-RM2019-F4 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TITR-RM2019-F4 +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Libraries;..\Mylib;..\User;..\CAN;..\ADC-DAC;..\TIM;..\MPU6050;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\OLED;..\MY_pan;.\can_task;.\chassis;.\gimbal;.\motor;.\PID;.\gas;..\VL53L0X;..\VL53L0X-2;.\vl53l0x;..\USART
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c Start.c
    ./can_task/: can_task.c
    ./chassis/: chassis.c
    ./gimbal/: gimbal.c
    ./motor/: motor.c
    ./PID/: pid.c
    ./gas/: gas.c
    ./vl53l0x/: VL53L0X_task.c
  group Libraries
    ../Libraries/: misc.c stm32f4xx_rng.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_rcc.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_usart.c stm32f4xx_syscfg.c system_stm32f4xx.c startup_stm32f4xx.s stm32f4xx_flash.c stm32f4xx_dac.c
    ../User/: stm32f4xx_it.c
  group Mylib
    ../Mylib/: delay.c Nvic.c dbus.c Judge.c laser.c led.c
  group USART
    ../USART/: usart1.c usart3.c uart4.c usart6.c
  group TIM
    ../TIM/: pwm1.c tim2.c
  group CAN
    ../CAN/: can1.c can2.c
  group MPU6050
    ../MPU6050/: mpu6050_driver.c mpu6050_i2c.c mpu6050_interrupt.c mpu6050_process.c
  group FreeROTS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group VL53L0X
    ../VL53L0X/: stmflash.c vl53l0x.c vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_cali.c vl53l0x_gen.c vl53l0x_i2c.c vl53l0x_it.c vl53l0x_platform.c
  group VL53L0X-2
    ../VL53L0X-2/: vl53l0x_2.c vl53l0x_api_2.c vl53l0x_api_calibration_2.c vl53l0x_api_core_2.c vl53l0x_api_ranging_2.c vl53l0x_api_strings_2.c vl53l0x_cali_2.c vl53l0x_gen_2.c vl53l0x_i2c_2.c vl53l0x_it_2.c vl53l0x_platform_2.c
software components: CMSIS:CORE 5.0.0
